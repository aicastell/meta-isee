PREMIRRORS = "${DEBIAN_MIRROR}/main/n/neon27/neon27_${PV}.orig.tar.gz"
