FILESEXTRAPATHS_prepend := "${THISDIR}/files:" 
PRINC = "1" 
PR := "${PR}.1"

#FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
#SPLASH_IMAGES = "file://psplash-poky-img.h"
