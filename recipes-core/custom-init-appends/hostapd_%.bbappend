INITSCRIPT_PARAMS = "start 20 2 3 4 . stop 20 0 1 5 ."
