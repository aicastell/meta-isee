PACKAGECONFIG += " \
    gstreamer \
"

